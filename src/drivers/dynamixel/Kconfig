## src/drivers/dynamixel/Kconfig
```kconfig
menuconfig DRIVERS_DYNAMIXEL
	bool "dynamixel"
	default n
	---help---
		Enable support for dynamixel
```
